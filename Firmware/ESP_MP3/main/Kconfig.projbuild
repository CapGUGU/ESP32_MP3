## Firmware/ESP_MP3/main/Kconfig.projbuild
```kconfig
# put here your custom config value
source "C:/Users/Li Yuanhao/Documents/GitHub/ESP32_MP3/Firmware/ESP_MP3/main/liveLED/liveLED.projbuild"
```
